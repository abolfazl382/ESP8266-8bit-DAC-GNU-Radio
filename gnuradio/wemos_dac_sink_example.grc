options:
  parameters:
    author: asus
    generate_options: qt_gui
    id: dac_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\pyprojects\arduino\01 Shame Mahtab.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import sys

      sys.path.insert(0, r"C:\pyprojects\arduino")

      from wemos_dac import WemosDAC


      class blk(gr.sync_block):

          def __init__(
              self,
              port="COM5",
              baudrate=2000000,
              sample_rate=100000,
              buffer_packets=20,
              ack_timeout=2.0
          ):
              gr.sync_block.__init__(
                  self,
                  name="Wemos DAC Sink",
                  in_sig=[np.float32],
                  out_sig=None
              )

              self.port = port
              self.baudrate = int(baudrate)
              self.sample_rate = int(sample_rate)
              self.buffer_packets = int(buffer_packets)
              self.ack_timeout = float(ack_timeout)

              self.dac = None
              self.work_count = 0

          def start(self):

              print("Wemos DAC: starting...", flush=True)

              self.dac = WemosDAC(
                  port=self.port,
                  baudrate=self.baudrate,
                  sample_rate=self.sample_rate,
                  buffer_packets=self.buffer_packets,
                  ack_timeout=self.ack_timeout
              )

              self.dac.start()

              print("Wemos DAC: started.", flush=True)

              return gr.sync_block.start(self)

          def work(self, input_items, output_items):

              samples = input_items[0]

              self.dac.write(samples)

              self.work_count += 1

              # فقط هر 100 بار یک پیام
              if self.work_count % 100 == 0:
                  print(
                      "Wemos DAC: received samples:",
                      self.work_count,
                      flush=True
                  )

              return len(samples)

          def stop(self):

              print("Wemos DAC: stopping...", flush=True)

              if self.dac is not None:

                  try:
                      self.dac.finish()
                  except Exception as e:
                      print("Wemos DAC finish error:", e)

                  self.dac.close()
                  self.dac = None

              print("Wemos DAC: stopped.", flush=True)

              return gr.sync_block.stop(self)
    ack_timeout: '2.0'
    baudrate: '2000000'
    buffer_packets: '20'
    port: '"COM5"'
    sample_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '1000'
    type: fff
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', epy_block_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
